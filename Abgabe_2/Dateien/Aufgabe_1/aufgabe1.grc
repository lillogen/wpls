options:
  parameters:
    generate_options: qt_gui
    id: aufgabe2
    output_language: python
    title: assignment2
  states: {}

blocks:
- name: audiogain
  id: variable_qtgui_range
  parameters:
    label: Volume
    min_len: '50'
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
    widget: slider
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: channel
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    label: Frequenz
    orient: Qt.Horizontal
    start: 85e6
    step: 0.05e6
    stop: 110e6
    value: channel_freq
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: senderauswahl
  states: {}
- name: channel_with
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: record
  id: variable_qtgui_chooser
  parameters:
    label: Recorder
    label0: Don't Record
    label1: Record
    num_opts: '2'
    option1: '0'
    type: raw
    value: '1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: senderauswahl
  id: variable_qtgui_chooser
  parameters:
    label: Sender
    label0: CT Radio
    label1: Radio Bochum
    label2: WDR 2
    num_opts: '3'
    option1: 98.5e6
    option2: 87.5e6
    orient: Qt.QHBoxLayout
    type: real
    value: 90e6
    widget: radio_buttons
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audiogain
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: record
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /tmp/music.wav
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: int(samp_rate / channel_with)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: channel
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: channel
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
