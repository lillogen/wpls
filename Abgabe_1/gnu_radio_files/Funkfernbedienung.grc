options:
  parameters:
    author: bschlueter
    generate_options: qt_gui
    id: Funkfernbe
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: curr_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 24e6
    step: 100e4
    stop: 1000e6
    value: 433.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: tofile
  id: variable_qtgui_check_box
  parameters:
    'false': 'True'
    label: Write to File
    'true': 'False'
    type: int
    value: 'True'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/signal.wav
    type: byte
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: tofile
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.09'
    init: '0'
    low: '0.09'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.09'
    init: '0'
    low: '0.09'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: curr_freq
    gain0: '15'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: magenta
    color2: yellow
    ctrlpanel: 'True'
    label1: Complex to Mag
    label2: complex to real
    label3: Shift Down
    nconnections: '3'
    size: '1024'
    srate: samp_rate/10
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_mute_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_real_1, '0', blocks_threshold_ff_0_0, '0']
- [blocks_mute_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_1, '0']

metadata:
  file_format: 1
